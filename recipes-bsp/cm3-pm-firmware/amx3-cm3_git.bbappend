# look for files in this layer first
FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001_2D00_CM3_2D00_ddr_2D00_Split_2D00_335x_2D00_and_2D00_437x_2D00_ddr_2D00_io_2D00_ctrl_2D00_handling.patch"
