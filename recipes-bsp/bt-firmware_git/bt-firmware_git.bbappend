# This recipe provides the latest bluetooth firmware files for wl12xx/wl18xx.
# It does not confilct with linux-firmware-wl12xx since it uses different repository.
RCONFLICTS_${PN} = ""
RREPLACES_${PN}  = ""

