PV = "1.5.7"
SRC_URI = "https://github.com/lpechacek/cpuset/archive/v${PV}.tar.gz"
 
SRC_URI[md5sum] = "6ad79b26ba03f559604d74513cc34392"
SRC_URI[sha256sum] = "32334e164415ed5aec83c5ffc3dc01c418406eb02d96d881fdfd495587ff0c01"

