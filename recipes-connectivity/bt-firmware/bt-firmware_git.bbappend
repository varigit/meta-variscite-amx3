# WL8 service pack v4.2
SRCREV = "c290f8af9e388f37e509ecb111a1b64572b7c225"
BRANCH = "master"

