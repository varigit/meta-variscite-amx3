LICENSE = "GPLv2"
LIC_FILES_CHKSUM = "file://../COPYING;md5=292eece3f2ebbaa25608eed8464018a3"

# Add TI to the end to make it clear that this is a TI customized version
# of hostap
PV = "R8.7_SP3-ti+git${SRCPV}"

# Tag: R8.7_SP3
SRCREV = "ee8fbdb840d95e048f58fb62bf3b5472041b5417"
BRANCH = "upstream_25_rebase"
