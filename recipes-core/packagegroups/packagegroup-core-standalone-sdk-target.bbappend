# removed libgcov-dev causing build error

RDEPENDS_${PN}_remove = "\
    libgcov-dev \
    "
