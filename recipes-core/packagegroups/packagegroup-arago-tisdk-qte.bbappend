#just remove examples not referred by matrix gui

QT5_DEMOS_remove = "\
    qt3d-examples \
    qtdeclarative-examples \
    qtdeclarative-tools \
    qtlocation-examples \
    qtmultimedia-examples \
    qtscript-examples \
    qtquick1-examples \
"
