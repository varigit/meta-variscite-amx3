WLAN_COMMON_remove = "\
    obexd \
    obex-client \
"

BLUETOOTH_STACK_remove = "\
    bluez4 \
    bluez4-agent \
    bluez-hcidump \
    uim \
"

BLUETOOTH_STACK_append = "\
    bluez5 \
"

