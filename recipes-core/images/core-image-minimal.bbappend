IMAGE_INSTALL_append = " kernel-modules packagegroup-arago-tisdk-connectivity"
