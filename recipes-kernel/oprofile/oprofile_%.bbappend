#just remove recommended dependecy to save about 100 MB

RRECOMMENDS_${PN}_remove = "kernel-vmlinux"
