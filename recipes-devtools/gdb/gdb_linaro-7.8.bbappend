SRC_URI_prepend = "http://releases.linaro.org/archive/14.09/components/toolchain/gdb-linaro/gdb-linaro-7.8-2014.09.tar.xz "
