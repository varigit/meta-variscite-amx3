SRC_URI_prepend = "http://releases.linaro.org/archive/15.01/components/toolchain/binutils-linaro/binutils-linaro-2.25.0-2015.01-2.tar.xz "
