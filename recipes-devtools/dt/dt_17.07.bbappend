SRC_URI = "https://github.com/varigit/gdblinaro/raw/master/dt-source.tar.gz"
